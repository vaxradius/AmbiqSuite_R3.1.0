# Keil uVision project ctimer_multi_bidirectional_stepper.uvprojx, settings and files
target ctimer_multi_bidirectional_stepper (ARM-ADS)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: ctimer_multi_bidirectional_stepper
  AfterMake: fromelf --bin --output bin\ctimer_multi_bidirectional_stepper.bin bin\ctimer_multi_bidirectional_stepper.axf
  AfterMake: fromelf -cedrst --output bin\ctimer_multi_bidirectional_stepper.txt bin\ctimer_multi_bidirectional_stepper.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PART_APOLLO3 AM_PACKAGE_BGA keil6
  c include: ../../../../../mcu/apollo3;../../../../../utils;../../../../../CMSIS/AmbiqMicro/Include;../../../bsp;../../../../..;../../../../../devices;../src;../../../../../CMSIS/ARM/Include
  memory RVCT4: ROM 0xC000 size 0xF4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\ctimer_multi_bidirectional_stepper.sct
  link misc: ../../../../../mcu/apollo3/hal/keil6/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data) --undefined=__scatterload_copy
  group src
    ../src/: ctimer_multi_bidirectional_stepper.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../mcu/apollo3/hal/keil6/bin/: libam_hal.lib
