# IAR project ble_freertos_amota_dtm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMA3B1KK-KBR AmbiqMicro AMA3B1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_CUSTOM_BDADDR; AM_MULTIBOOT_CONFIG_FILE="amota_profile_config.h"; WSF_TRACE_ENABLED; AM_PART_APOLLO3; SEC_ECC_CFG=SEC_ECC_CFG_HCI; AM_DEBUG_PRINTF; AM_FREERTOS
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\third_party\cordio\ble-host\sources\stack\dm; ..\..\..\..\..\third_party\cordio\ble-profiles\sources\apps\app; ..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\third_party\cordio\ble-host\sources\stack\hci; ..\..\..\..\..\third_party\cordio\wsf\sources\util; ..\..\..\..\..\third_party\cordio\ble-profiles\sources\profiles\hrps; ..\..\..\..\..\ambiq_ble\profiles\amota; ..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\portable\IAR\AMapollo2; ..\..\..\..\..\third_party\cordio\wsf\include; ..\..\..\..\..\ambiq_ble\apps\amota; ..\..\..\..\..\third_party\cordio\ble-host\sources\stack\att; ..\..\..\..\..\third_party\cordio\ble-host\sources\stack\smp; ..\..\..\..\..; ..\..\..\..\..\third_party\cordio\ble-host\sources\hci\ambiq\apollo3; ..\..\..\..\..\third_party\cordio\ble-host\sources\hci\ambiq; ..\..\..\..\..\third_party\cordio\ble-host\sources\stack\cfg; ..\..\..\..\..\third_party\cordio\ble-host\sources\sec\common; ..\..\..\..\..\third_party\cordio\ble-profiles\sources\profiles\include; ..\..\..\..\..\devices; ..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\third_party\cordio\ble-profiles\sources\apps; ..\..\..\..\..\bootloader; ..\..\..\..\..\ambiq_ble\services; ..\..\..\..\..\third_party\cordio\ble-profiles\sources\profiles\bas; ..\..\..\..\..\third_party\cordio\ble-profiles\sources\profiles; ..\..\..\..\..\third_party\cordio\ble-profiles\sources\profiles\uribeacon; ..\..\..\..\..\utils; ..\..\..\..\..\third_party\cordio\ble-profiles\sources\profiles\gap; ..\..\..\..\..\third_party\cordio\ble-host\include; ..\..\..\..\..\mcu\apollo3; ..\..\..\..\..\third_party\cordio\ble-host\sources\stack\l2c; ..\..\..\..\..\third_party\cordio\wsf\sources; ..\..\..\..\..\third_party\cordio\ble-profiles\include\app; ..\..\..\..\..\third_party\cordio\ble-profiles\sources\profiles\rscp; ..\..\..\bsp; ..\..\..\..\..\third_party\cordio\ble-profiles\sources\profiles\gatt; ..\..\..\..\..\third_party\cordio\ble-profiles\sources\profiles\hid; ..\..\..\..\..\third_party\uecc; ..\..\..\..\..\third_party\cordio\wsf\sources\port\freertos; ..\..\..\..\..\third_party\cordio\ble-profiles\sources\services; ..\src; ..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ble_freertos_amota_dtm.bin
  ILINK.IlinkOutputFile: ble_freertos_amota_dtm.out
  ILINK.IlinkIcfFile: ble_freertos_amota_dtm.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\mcu\apollo3\hal\iar\bin\libam_hal.a; ..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; AM_CUSTOM_BDADDR; AM_MULTIBOOT_CONFIG_FILE="amota_profile_config.h"; WSF_TRACE_ENABLED; AM_PART_APOLLO3; SEC_ECC_CFG=SEC_ECC_CFG_HCI; AM_DEBUG_PRINTF; AM_FREERTOS
  group (top)
    ../../../../../third_party/cordio/ble-host/sources/stack/dm/: dm_adv.c dm_adv_ae.c dm_adv_leg.c dm_bis_master.c dm_bis_slave.c dm_cis.c dm_cis_master.c dm_cis_slave.c dm_cis_sm.c dm_conn.c dm_conn_cte.c dm_conn_master.c dm_conn_master_ae.c dm_conn_master_leg.c dm_conn_slave.c dm_conn_slave_ae.c dm_conn_slave_leg.c dm_conn_sm.c dm_dev.c dm_dev_priv.c dm_iso.c dm_main.c dm_past.c dm_phy.c dm_priv.c dm_scan.c dm_scan_ae.c dm_scan_leg.c dm_sec.c dm_sec_lesc.c dm_sec_master.c dm_sec_slave.c dm_sync_ae.c
    ../../../../../ambiq_ble/services/: svc_amdtp.c svc_amotas.c svc_amvole.c svc_cust.c svc_throughput.c
    ../../../../../third_party/cordio/ble-profiles/sources/profiles/bas/: bas_main.c
    ../../../../../third_party/cordio/ble-profiles/sources/apps/hidapp/: hidapp_main.c
    ../../../../../third_party/cordio/ble-profiles/sources/profiles/gap/: gap_main.c
    ../../../../../third_party/cordio/ble-host/sources/stack/hci/: hci_main.c
    ../../../../../third_party/cordio/wsf/sources/util/: bda.c bstream.c calc128.c crc32.c print.c terminal.c wstr.c
    ../../../../../ambiq_ble/profiles/amota/: amotas_main.c
    ../../../../../third_party/cordio/ble-profiles/sources/profiles/hrps/: hrps_main.c
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/IAR/AMapollo2/: port.c portasm.s
    ../../../../../ambiq_ble/apps/amota/: amota_main.c
    ../../../../../third_party/cordio/ble-host/sources/stack/smp/: smpi_act.c smpi_sc_act.c smpi_sc_sm.c smpi_sm.c smpr_act.c smpr_sc_act.c smpr_sc_sm.c smpr_sm.c smp_act.c smp_db.c smp_main.c smp_non.c smp_sc_act.c smp_sc_main.c
    ../../../../../third_party/cordio/ble-host/sources/stack/att/: attc_disc.c attc_eatt.c attc_main.c attc_proc.c attc_read.c attc_sign.c attc_write.c atts_ccc.c atts_csf.c atts_dyn.c atts_eatt.c atts_ind.c atts_main.c atts_proc.c atts_read.c atts_sign.c atts_write.c att_eatt.c att_main.c att_uuid.c
    ../../../../../third_party/cordio/ble-host/sources/sec/uecc/: sec_ecc.c
    ../../../../../third_party/cordio/ble-host/sources/stack/l2c/: l2c_coc.c l2c_main.c l2c_master.c l2c_slave.c
    ../../../../../third_party/cordio/ble-profiles/sources/profiles/rscp/: rscps_main.c
    ../../../../../third_party/cordio/ble-host/sources/hci/ambiq/apollo3/: hci_drv_apollo3.c hci_vs_apollo3.c
    ../../../../../third_party/uecc/: uECC.c uECC_ll.c
    ../../../../../third_party/cordio/ble-profiles/sources/profiles/hid/: hid_main.c
    ../../../../../third_party/cordio/ble-profiles/sources/profiles/gatt/: gatt_main.c
    ../../../../../third_party/cordio/ble-profiles/sources/apps/app/common/: app_db.c app_hw.c app_ui.c ui_console.c ui_lcd.c ui_main.c ui_platform.c ui_timer.c
    ../../../../../third_party/cordio/ble-host/sources/hci/ambiq/: hci_cmd.c hci_cmd_ae.c hci_cmd_bis.c hci_cmd_cis.c hci_cmd_cte.c hci_cmd_iso.c hci_cmd_past.c hci_cmd_phy.c hci_core.c hci_core_ps.c hci_evt.c hci_tr.c hci_vs_ae.c
    ../../../../../third_party/cordio/wsf/sources/port/freertos/: wsf_assert.c wsf_buf.c wsf_efs.c wsf_math.c wsf_msg.c wsf_os.c wsf_queue.c wsf_timer.c wsf_trace.c
    ../../../../../third_party/cordio/ble-host/sources/stack/cfg/: cfg_stack.c
    ../../../../../third_party/cordio/ble-host/sources/sec/common/: sec_aes.c sec_aes_rev.c sec_ccm_hci.c sec_cmac_hci.c sec_ecc_debug.c sec_ecc_hci.c sec_main.c
    ../src/: ble_freertos_amota.c radio_task.c rtos.c uart_ble_bridge_dtm.c
    ../../../../../utils/: am_util_ble.c am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c
    ../../../../../bootloader/: am_bootloader.c am_multi_boot.c
    ../../../../../third_party/cordio/ble-profiles/sources/services/: svc_alert.c svc_batt.c svc_bps.c svc_core.c svc_cps.c svc_cscs.c svc_cte.c svc_dis.c svc_gls.c svc_gyro.c svc_hid.c svc_hrs.c svc_hts.c svc_ipss.c svc_plxs.c svc_px.c svc_rscs.c svc_scpss.c svc_temp.c svc_time.c svc_uricfg.c svc_wdxs.c svc_wp.c svc_wss.c
    ../../../../../third_party/FreeRTOSv10.1.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/cordio/ble-profiles/sources/apps/app/: app_disc.c app_main.c app_master.c app_master_ae.c app_master_leg.c app_server.c app_slave.c app_slave_ae.c app_slave_leg.c app_terminal.c
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_2.c
    ../../../../../devices/: am_devices_button.c am_devices_led.c
    ./: startup_iar.c
