# Keil uVision project cache_monitor.uvprojx, settings and files
target cache_monitor (ARM-ADS)
  device: AMA3B2KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.0
  cpu: IRAM(0x10000000,0x000C0000) IROM(0x0000C000,0x001F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: cache_monitor
  AfterMake: fromelf --bin --output bin\cache_monitor.bin bin\cache_monitor.axf
  AfterMake: fromelf -cedrst --output bin\cache_monitor.txt bin\cache_monitor.axf
  c flags: Optim=6 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PACKAGE_BGA APS6404L AM_PRINTF_BUFSIZE=256 AM_PART_APOLLO3P keil6
  c include: ../../../../..;../../../../../devices;../../../../../mcu/apollo3p;../../../../../CMSIS/AmbiqMicro/Include;../src;../../../bsp;../../../../../CMSIS/ARM/Include;../../../../../utils
  memory RVCT4: ROM 0xc000 size 0x1f4000
  memory RVCT9: RAM 0x10000000 size 0xc0000
  scatter file: .\linker_script.sct
  link misc: ../../../../../mcu/apollo3p/hal/keil6/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data) --undefined=__scatterload_copy
  group src
    ../src/: cache_monitor.c
  group prime_mpi_src
    ../../../../../third_party/prime_mpi/src/: prime_mpi.c
  group devices
    ../../../../../devices/: am_devices_mspi_psram_aps6404l.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../mcu/apollo3p/hal/keil6/bin/: libam_hal.lib
