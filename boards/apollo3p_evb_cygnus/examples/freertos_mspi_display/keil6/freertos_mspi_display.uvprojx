# Keil uVision project freertos_mspi_display.uvprojx, settings and files
target freertos_mspi_display (ARM-ADS)
  device: AMA3B2KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.0
  cpu: IRAM(0x10000000,0x000C0000) IROM(0x0000C000,0x001F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: freertos_mspi_display
  AfterMake: fromelf --bin --output bin\freertos_mspi_display.bin bin\freertos_mspi_display.axf
  AfterMake: fromelf -cedrst --output bin\freertos_mspi_display.txt bin\freertos_mspi_display.axf
  c flags: Optim=6 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_FREERTOS AM_DEBUG_PRINTF AM_UTIL_FAULTISR_PRINT AM_PACKAGE_BGA AM_PART_APOLLO3P keil6
  c include: ../../../../../utils;../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil6/AMapollo2;../../../../../CMSIS/AmbiqMicro/Include;../../../../../CMSIS/ARM/Include;../../../../../third_party/FreeRTOSv10.1.1/Source/include;../src;../../../../..;../../../../../devices;../../../../../mcu/apollo3p;../../../bsp
  memory RVCT4: ROM 0xc000 size 0x1f4000
  memory RVCT9: RAM 0x10000000 size 0xc0000
  scatter file: .\linker_script.sct
  link misc: ../../../../../mcu/apollo3p/hal/keil6/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data) --undefined=__scatterload_copy
  group image
    ../src/image/: ambiq_logo.c NeZa1.c NeZa2.c watch_background.c
  group FreeRTOSv10.1.1_AMapollo2
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil6/AMapollo2/: port.c
  group src
    ../src/: freertos_mspi_display.c main_task.c render_task.c rtos.c
  group FreeRTOSv10.1.1_Source
    ../../../../../third_party/FreeRTOSv10.1.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOSv10.1.1_MemMang
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_2.c
  group utils
    ../../../../../utils/: am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group devices
    ../../../../../devices/: am_devices_mspi_rm69330.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../mcu/apollo3p/hal/keil6/bin/: libam_hal.lib
    ../../../bsp/keil6/bin/: libam_bsp.lib
