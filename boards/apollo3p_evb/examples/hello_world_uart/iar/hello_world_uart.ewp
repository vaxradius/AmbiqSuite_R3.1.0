# IAR project hello_world_uart.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMA3B2KK-KBR AmbiqMicro AMA3B2KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PART_APOLLO3P; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\mcu\apollo3p; ..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..; ..\src; ..\..\..\..\..\utils; ..\..\..\..\..\devices; ..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\bsp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: hello_world_uart.bin
  ILINK.IlinkOutputFile: hello_world_uart.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\mcu\apollo3p\hal\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PART_APOLLO3P; AM_PACKAGE_BGA
  group (top)
    ../src/: hello_world_uart.c
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c
    ./: startup_iar.c
