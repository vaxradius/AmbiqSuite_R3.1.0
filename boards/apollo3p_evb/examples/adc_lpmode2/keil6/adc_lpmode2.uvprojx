# Keil uVision project adc_lpmode2.uvprojx, settings and files
target adc_lpmode2 (ARM-ADS)
  device: AMA3B2KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.0
  cpu: IRAM(0x10000000,0x000C0000) IROM(0x0000C000,0x001F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: adc_lpmode2
  AfterMake: fromelf --bin --output bin\adc_lpmode2.bin bin\adc_lpmode2.axf
  AfterMake: fromelf -cedrst --output bin\adc_lpmode2.txt bin\adc_lpmode2.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PACKAGE_BGA AM_PART_APOLLO3P keil6
  c include: ../src;../../../bsp;../../../../../utils;../../../../../CMSIS/AmbiqMicro/Include;../../../../..;../../../../../mcu/apollo3p;../../../../../devices;../../../../../CMSIS/ARM/Include
  memory RVCT4: ROM 0xc000 size 0x1f4000
  memory RVCT9: RAM 0x10000000 size 0xc0000
  scatter file: .\linker_script.sct
  link misc: ../../../../../mcu/apollo3p/hal/keil6/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data) --undefined=__scatterload_copy
  group src
    ../src/: adc_lpmode2.c
  group devices
    ../../../../../devices/: am_devices_led.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../mcu/apollo3p/hal/keil6/bin/: libam_hal.lib
