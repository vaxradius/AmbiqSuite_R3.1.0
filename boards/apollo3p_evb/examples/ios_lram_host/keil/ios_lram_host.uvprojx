# Keil uVision project ios_lram_host.uvprojx, settings and files
target ios_lram_host (ARM-ADS)
  device: AMA3B2KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.0
  cpu: IRAM(0x10000000,0x000C0000) IROM(0x0000C000,0x001F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: ios_lram_host
  AfterMake: fromelf --bin --output bin\ios_lram_host.bin bin\ios_lram_host.axf
  AfterMake: fromelf -cedrst --output bin\ios_lram_host.txt bin\ios_lram_host.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PART_APOLLO3P AM_PACKAGE_BGA keil
  c include: ../../../../..;../../../../../CMSIS/AmbiqMicro/Include;../src;../../../../../devices;../../../../../utils;../../../../../mcu/apollo3p;../../../bsp;../../../../../CMSIS/ARM/Include
  memory RVCT4: ROM 0xc000 size 0x1f4000
  memory RVCT9: RAM 0x10000000 size 0xc0000
  scatter file: .\linker_script.sct
  link misc: ../../../../../mcu/apollo3p/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: ios_lram_host.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../mcu/apollo3p/hal/keil/bin/: libam_hal.lib
    ../../../bsp/keil/bin/: libam_bsp.lib
