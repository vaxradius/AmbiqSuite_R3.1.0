# Keil uVision project freertos_mspi_display.uvprojx, settings and files
target freertos_mspi_display (ARM-ADS)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: freertos_mspi_display
  AfterMake: fromelf --bin --output bin\freertos_mspi_display.bin bin\freertos_mspi_display.axf
  AfterMake: fromelf -cedrst --output bin\freertos_mspi_display.txt bin\freertos_mspi_display.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA AM_FREERTOS AM_PART_APOLLO3 AM_UTIL_FAULTISR_PRINT AM_DEBUG_PRINTF keil
  c include: ../../../../../mcu/apollo3;../../../../../CMSIS/AmbiqMicro/Include;../../../../../third_party/FreeRTOSv10.1.1/Source/include;../src;../../../../..;../../../../../CMSIS/ARM/Include;../../../../../devices;../../../../../utils;../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo2;../../../bsp
  memory RVCT4: ROM 0xC000 size 0xF4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\freertos_mspi_display.sct
  link misc: ../../../../../mcu/apollo3/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: freertos_mspi_display.c main_task.c render_task.c rtos.c
  group image
    ../src/image/: ambiq_logo.c NeZa1.c NeZa2.c watch_background.c
  group FreeRTOSv10.1.1_AMapollo2
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo2/: port.c
  group devices
    ../../../../../devices/: am_devices_mspi_rm69330.c
  group utils
    ../../../../../utils/: am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group FreeRTOSv10.1.1_MemMang
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_2.c
  group FreeRTOSv10.1.1_Source
    ../../../../../third_party/FreeRTOSv10.1.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../mcu/apollo3/hal/keil/bin/: libam_hal.lib
